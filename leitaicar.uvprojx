# Keil uVision project leitaicar.uvprojx, settings and files
target leitaicar (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: leitaicar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/SYSTEM;../BSP/HARDWARE/LED;../BSP/HARDWARE/KEY;../BSP/HARDWARE/BEEP;../BSP/HARDWARE/SERVOR_BC;../BSP/HARDWARE/TIMER;../BSP/HARDWARE/PWM;../BSP/HARDWARE/SENSOR;../BSP/HARDWARE/LCD;../BSP/APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group BSP
    ../BSP/SYSTEM/: sys.c delay.c
    ../BSP/HARDWARE/LED/: led.c
    ../BSP/HARDWARE/KEY/: key.c
    ../BSP/HARDWARE/BEEP/: beep.c
    ../BSP/HARDWARE/SERVOR_BC/: servor_bc.c
    ../BSP/HARDWARE/TIMER/: timer.c
    ../BSP/HARDWARE/PWM/: pwm.c
    ../BSP/HARDWARE/SENSOR/: sensor.c
    ../BSP/HARDWARE/LCD/: lcd.c
    ../BSP/APP/: init.c ysy.c edge.c AD_Detection.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
